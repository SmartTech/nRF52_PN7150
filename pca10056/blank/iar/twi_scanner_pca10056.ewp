# IAR project twi_scanner_pca10056.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52840_XXAA
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\timer; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\drivers_nrf\twi_master; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\experimental_log; ..\..\..\..\..\..\components\libraries\experimental_log\src; ..\..\..\..\..\..\components\libraries\experimental_memobj; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\external\segger_rtt; ..\config; ..\..\..\PN7120; ..\..\..\PN7120\library\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\drivers_nrf\twi_master; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\experimental_log; ..\..\..\..\..\..\components\libraries\experimental_log\src; ..\..\..\..\..\..\components\libraries\experimental_memobj; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\external\segger_rtt; ..\config
  OBJCOPY.OOCOutputFile: twi_scanner_pca10056.hex
  ILINK.IlinkOutputFile: twi_scanner_pca10056.out
  ILINK.IlinkIcfFile: twi_scanner_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../: main.c
    ../../../PN7120/: nfc_demo.c nfc_demo.h
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf52840.s
    ../../../../../../components/toolchain/: system_nrf52840.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group PN7150
    ../../../PN7120/library/src/: nfc.c nfc_hal.c P2P_NDEF.c RW_NDEF.c RW_NDEF_T1T.c RW_NDEF_T2T.c RW_NDEF_T3T.c RW_NDEF_T4T.c T4T_NDEF_EMU.c
  group PN7150/include
    ../../../PN7120/library/include/: nfc.h nfc_hal.h P2P_NDEF.h RW_NDEF.h RW_NDEF_T1T.h RW_NDEF_T2T.h RW_NDEF_T3T.h RW_NDEF_T4T.h T4T_NDEF_EMU.h
